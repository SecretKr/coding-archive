#include <stdio.h>
#include <string.h>

int main()
{
    int i,i2,sa,z;
    char a[15];
    char b[75][5];

    scanf("%s",&a);
    sa = strlen(a);

    char k0[] = {'.', '.', '#', '.', '.'};
    char k1[] = {'.', '#', '.', '#', '.'};
    char k2[] = {'#', '.', '&', '.', '#'};
    char k3[] = {'.', '#', '.', '#', '.'};
    char k4[] = {'.', '.', '#', '.', '.'};

    char q0[] = {'.', '.', '*', '.', '.'};
    char q1[] = {'.', '*', '.', '*', '.'};
    char q2[] = {'*', '.', '&', '.', '*'};
    char q3[] = {'.', '*', '.', '*', '.'};
    char q4[] = {'.', '.', '*', '.', '.'};

    for(i2 = 0;i2 < sa;i2++ )
        for(i = 0;i < 4;i++ ){
            b[i2*4+i][0] = k0[i];
            b[i2*4+i][1] = k1[i];
            b[i2*4+i][2] = k2[i];
            b[i2*4+i][3] = k3[i];
            b[i2*4+i][4] = k4[i];}

    for(i2 = 1;i2 < 6;i2++ )
        if(i2 == 1)
            for(i = 0;i < 5;i++ ){
                b[8+i][0] = q0[i];
                b[8+i][1] = q1[i];
                b[8+i][2] = q2[i];
                b[8+i][3] = q3[i];
                b[8+i][4] = q4[i];}
        else
            for(i = 0;i < 5;i++ ){
                b[i2*12-4+i][0] = q0[i];
                b[i2*12-4+i][1] = q1[i];
                b[i2*12-4+i][2] = q2[i];
                b[i2*12-4+i][3] = q3[i];
                b[i2*12-4+i][4] = q4[i];}

    for(z = 0;z < sa;z++)
        b[4*z+2][2] = a[z];

    if(sa%3 == 0)
        sa = sa;
    else{
        b[sa*4][0] = '.';
        b[sa*4][1] = '.';
        b[sa*4][2] = '#';
        b[sa*4][3] = '.';
        b[sa*4][4] = '.';}
    for(i2 = 0; i2 < 5;i2++){
        for(i = 0;i < sa*4+1;i++ )
            printf("%c", b[i][i2]);
        printf("\n");}
}
